# IAR project Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx; ARM_MATH_CM4
  ICCARM.CCDiagSuppress: Pa082,Pa093,Pe301
  ICCARM.CCIncludePath2: ..\..\Application; ..\..\System; ..\..\Libraries\inc; ..\..\Drivers\inc; ..\..\Drivers\Common; ..\..\System\Include; ..\..\System\IAR; ..\..\EMWIN\STemWin\inc; ..\..\EMWIN\STemWin\Config; ..\..\EMWIN\Demo; ..\..\FATFS\exfuns; ..\..\FATFS\src; ..\..\USMART\; ..\..\AUDIOCODEC\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.hex
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Application
    ../../Application/: audioplay.c main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group AUDIO
    ../../AUDIOCODEC/src/: wavplay.c
  group Drivers/inc
    ../../Drivers/inc/: at24cxx.h delay.h font.h fontupd.h lcd.h led.h malloc.h sdio_sdcard.h spi.h sram.h sys.h text.h timer.h touch.h usart.h w25qxx.h
  group Drivers/src
    ../../Drivers/src/: AD7705.c adc.c at24cxx.c dac.c delay.c fontupd.c hz_text.c key.c lcd.c led.c malloc.c nRF24L01.c RC522.c sdio_sdcard.c spi.c sram.c sys.c timer.c touch.c usart.c w25qxx.c
  group FATFS
    ../../FATFS/src/option/: cc936.c
    ../../FATFS/src/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../../FATFS/exfuns/: exfuns.c exfuns.h fattester.c fattester.h
  group Libraries/inc
    ../../Libraries/inc/: misc.h stm32f4xx_adc.h stm32f4xx_can.h stm32f4xx_cec.h stm32f4xx_crc.h stm32f4xx_cryp.h stm32f4xx_dac.h stm32f4xx_dbgmcu.h stm32f4xx_dcmi.h stm32f4xx_dma.h stm32f4xx_dma2d.h stm32f4xx_exti.h stm32f4xx_flash.h stm32f4xx_flash_ramfunc.h stm32f4xx_fmc.h stm32f4xx_fmpi2c.h stm32f4xx_fsmc.h stm32f4xx_gpio.h stm32f4xx_hash.h stm32f4xx_i2c.h stm32f4xx_iwdg.h stm32f4xx_ltdc.h stm32f4xx_pwr.h stm32f4xx_qspi.h stm32f4xx_rcc.h stm32f4xx_rng.h stm32f4xx_rtc.h stm32f4xx_sai.h stm32f4xx_sdio.h stm32f4xx_spdifrx.h stm32f4xx_spi.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h stm32f4xx_wwdg.h
  group Libraries/src
    ../../Libraries/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STemwin/EMWIN_Config
    ../../EMWIN/STemWin/OS/: GUI_X.c
    ../../EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
  group STemwin/EMWIN_Demo
    ../../EMWIN/Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_Touch.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group STemwin/EMWIN_LIB
    ../../EMWIN/STemWin/Lib/: emWin_M4F.a
  group System
    ../../System/iar/: startup_stm32f40_41xxx.s
    ../../System/: stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h
  group USMART
    ../../USMART/: usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
